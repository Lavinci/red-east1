# Keil uVision project YH-F103.uvprojx, settings and files
target FWLIB-Template (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Robot +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\User;..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\SYSTEM\delay;..\User\HARDWARE\LED;..\User\HARDWARE\KEY;..\User\HARDWARE\OLED;..\User\HARDWARE\USARTX;..\User\SYSTEM\usart;..\User\HARDWARE\ADC;..\User\HARDWARE\TIMER;..\User\HARDWARE\MOTOR;..\User\HARDWARE\ENCODER;..\User\HARDWARE\IIC;..\User\HARDWARE\MPU6050;..\User\HARDWARE\show;..\User\HARDWARE\EXTI;..\User\HARDWARE\DataScope_DP;..\User\HARDWARE\CAN;..\User\HARDWARE\STMFLASH;..\User\HARDWARE\DMP;..\User\HARDWARE\ENCODER;..\User\HARDWARE\CONTROL;..\User\HARDWARE\filter;..\User\HARDWARE\Servo;..\User\HARDWARE\Camera;..\User\HARDWARE\HCSR04
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h sys.c sys.h mine.c mine.h sensor.c sensor.h
    ../User/SYSTEM/delay/: delay.c delay.h
    ../User/HARDWARE/LED/: LED.C LED.H
    ../User/HARDWARE/KEY/: key.c key.h
    ../User/HARDWARE/OLED/: oled.c oled.h oledfont.h
    ../User/SYSTEM/usart/: usart.c usart.h
    ../User/HARDWARE/ADC/: adc.c adc.h
    ../User/HARDWARE/MOTOR/: motor.c motor.h
    ../User/HARDWARE/ENCODER/: encoder.c encoder.h
    ../User/HARDWARE/IIC/: IOI2C.c IOI2C.h
    ../User/HARDWARE/show/: show.c show.h
    ../User/HARDWARE/EXTI/: exti.c exti.h
    ../User/HARDWARE/DataScope_DP/: DataScope_DP.C DataScope_DP.h
    ../User/HARDWARE/STMFLASH/: stmflash.c stmflash.h
    ../User/HARDWARE/DMP/: dmpKey.h dmpmap.h inv_mpu.c inv_mpu.h inv_mpu_dmp_motion_driver.c inv_mpu_dmp_motion_driver.h
    ../User/HARDWARE/CONTROL/: control.c control.h
    ../User/HARDWARE/filter/: filter.c filter.h
    ../User/HARDWARE/Servo/: Servo.c Servo.h
    ../User/HARDWARE/Camera/: camera.c camera.h
    ../User/HARDWARE/HCSR04/: hcsr04.c
  group DOC
    ../DOC/: 程序说明.txt
